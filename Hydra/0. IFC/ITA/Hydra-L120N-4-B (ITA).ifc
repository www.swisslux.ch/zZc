Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numero del progetto
Time: 2022-07-05T17:26:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 05 17:26:55 2022 * Host: ENA567 * Database: C:\Users\admin\AppData\Local\Temp\{C397E217-E746-4FFC-B236-386C711502E6}\ifc * Database version: 5507 * Database creation date: Tue Jul 05 17:26:55 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 05 17:26:55 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 05 17:26:55 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numero del progetto
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Via ## Città (Provincia) C.A.P.; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: Numero del progetto; Stato del progetto: Stato del progetto
Dati identità - Workset: Informazioni progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Via ## Città (Provincia) C.A.P.; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: Numero del progetto; Stato del progetto: Stato del progetto
Dati identità - Workset: Informazioni progetto

# IfcBuildingStorey, Livello 1
LongName: Livello 1; Elevation: 0 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Cerchio: M_Estremità del livello - Cerchio; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Estremità 8 mm; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: Livello: Estremità 8 mm; Tipo: Livello: Estremità 8 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no; Workset: Griglie e livelli condivisi
Dimensioni - Altezza di calcolo: 0 mm
Vincoli - Quota altimetrica: 0 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Estremità 8 mm; Workset: Tipi di livello

# IfcBuildingElementProxy: Hydra-L120N-4-B, Hydra-L120N-4-B (ITA):Hydra-L120N-4-B:295146
In: Livello 1
Type - Material: PC, Acrylglas
Type - Altro - Categoria: Apparecchi per illuminazione; Adatto per fissaggio a soffitto: si; Adatto per l'installazione su superfici: si; Adatto per luce d'emergenza: si; Adatto per montaggio a parete: si; Adatto per sospensione: si; Adatto per trasmissione senza fili: si; Alimentazione: LED; Altezza di montaggio massima [m]: 10; Altezza di montaggio minima [m]: 2; Altezza di montaggio ottimale [m]: 2,5-3; Apparecchio cablato: si; Applicazione: Ambiente interno, Esterno; Certificazione: CE; Classe di efficienza energetica di sytema per l'etichettatura energetica 2021: E; Classe isolamento: I; Codice articolo: 162816; Coerenza dei colori in ellissi di MacAdam [SDCM]: 3; Collegamento: morsetto; Colore dell'apparecchio: grigio; Con fotocellula: si; Con lampada inclusa: si; Con sensore di movimento: si; Consumo di energia in modo acceso 1000 h [kW/h]: 40.4; Corpo illuminante: LED; Efficienza [lm/W]: 130,94; Emissione della luce diretta-indiretta: 92% / 8%; E-NR: 941001529; Entrata 1: Tasto / entrata slave; Entrata 2: Tasto / entrata slave; Flusso luminoso [lm]: 4600; Flusso luminoso luce d'emergenza [lm]: 460; Frequenza di alimentazione [Hz]: 50-60; Garanzia [j]: 5; Garanzia sulla batteria[j]: 0; Grado di protezione [IP]: 66; Idoneo ad essere ricoperto con materiali isolanti: -; Indice di resa cromatica (CRI): >80; Luce d'emergenza: con 230 V; Luminosità regolabile: si; Lunghezza massima del filo dati «D» [km]: 1; Max. gamma di presenza [m]: 1.5; Max. portata da un lato [m]: 5; Max. portata frontale [m]: 1.5; Metrica dell'effetto stroboscopico: NA; Metrica dello sfarfallio: NA; Nome famiglia: Hydra-L120N-4-B (ITA); Numero massimo di lampade sul disgiuntore di potenza: LS 10 A (B): 21 Pc.; Numero massimo di lampade sul disgiuntore di potenza: LS 16 A (B): 16 Pc.; Potenza in modo stand-by [W]: 1.183; Potenza totale [W]: 40.4 W; Programma di fabbrica: si; Resistente ai raggi UV: si; Sospensione fornita: no; Teleomandabile: con IR-Bluetooth Dongle (IR-Connect), con App Swisslux (iOS, Android); Temperatura di colore [K]: 4000; Tipo di cablaggio: passante; Tipo di montaggio, luogo di montaggio, dati: Montaggio fuori muro a soffitto umido; Tipo di tensione: AC; Unità di controllo: TRIVALITE; Uscita della luce: diretta; Vita utile misurazioni L70/B10 a 25 °C [h]: 50000; Zona di rilevamento: 360
Type - Dati identità - Modificato da: anton.ohamuk; Nome del tipo: Hydra-L120N-4-B; Produttore: SWISSLUX; URL: https://www.swisslux.ch/r/uLl; Workset: Famiglia : Apparecchi per illuminazione : Hydra-L120N-4-B (ITA)
Type - Dimensioni - Larghezza della lampada: 120 mm; Larghezza simbolo: 2.4 mm; Lunghezza della lampada: 1160 mm; Lunghezza del simbolo: 23.2 mm; Scala dei simboli: 50 mm
Type - Elettrico - ADSK_Classificazione dei carichi: Beleuchtung; ADSK_Fattore di potenza: 0.95; ADSK_Numero di fasi: 1; ADSK_Numero di fasi numerico: 1; ADSK_Piena potenza: 42.5263 W; ADSK_Potenza nominale: 40.4 W; ADSK_Tensione: 230 V; ADSK_Сorrente: 0.184897 A
Type - Fotometrica - Angolo inclinazione: 90 deg; Colore iniziale: 0; Definizione sorgente d'illuminazione (famiglia): Rettangolo+Diagramma fotometrico; Efficacia: 148.542 s3*lm/kg/m2; Emetti da larghezza rettangolo: 100 mm; Emetti da lunghezza rettangolo: 1140 mm; Fattore di perdita di illuminazione: 0; Fattore totale di perdita di illuminazione: 1; File diagramma fotometrico: Hydra-L120N-4-B_LDT.ies; Filtro dei colori: 16777215; Flusso luminoso: 4600 lm; Illuminanza: 39.402 lx; Intensità iniziale: 0; Intensità luminosa: 366.056 cd; Rendi la forma visibile nel rendering: no; Temperatura colore iniziale: 4000 K; Variazione temperatura colore lampada con luminosità attenuata: <Nessuno>; Watt: 30.9677 W
Type - Ingegneria elettrica - Tensione nominale: 230 V
Type - Materiali e finiture - Materiale della copertura: PC_; Materiale della custodia: PC
Type - Vincoli - Prospetto di default: 0 mm
Pset_BuildingElementProxyCommon - Reference: Hydra-L120N-4-B
Pset_ManufacturerTypeInformation - Manufacturer: SWISSLUX
Altro - Famiglia: Hydra-L120N-4-B (ITA): Hydra-L120N-4-B; Famiglia e tipo: Hydra-L120N-4-B (ITA): Hydra-L120N-4-B; ID tipo: Hydra-L120N-4-B (ITA): Hydra-L120N-4-B; Livello abaco: Livello: Livello 1; Tipo: Hydra-L120N-4-B (ITA): Hydra-L120N-4-B
Dati identità - Contrassegno: 22; Workset: Workset1
Dimensioni - Diametro del tubo vuoto: 20 mm; Volume: 0.0128308 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-43 VA
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: Livello 1; Offset: 0 mm; Piano di lavoro: Pavimento : Pavimento generico - 400 mm
